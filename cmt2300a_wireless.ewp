# IAR project cmt2300a_wireless.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151G6 STM8L151G6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: Libraries\inc; user\inc; radio; platform; periph; services
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: cmt2300a_wireless.hex
  ILINK.IlinkOutputFile: cmt2300a_wireless.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group platform
    platform/: stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h
  group radio
    radio/: cmt2300a.c cmt2300a_hal.c cmt2300a_params.h radio.c
  group user
    user/src/: cmt2300a_app.c main.c spi.c sys.c timer.c
    user/inc/: gpio_defs.h
