# IAR project Backup of Bunka STM8S003F3 TX Source.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151C6 STM8L151C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L051
  ICCSTM8.CCIncludePath2: Projects\inc; Libraries\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: bigua new.hex
  ILINK.IlinkOutputFile: Bunka STM8S003F3 TX Source.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    Projects/src/: ad.c adf7012.c eeprom.c eeprom_cyw.c EXIT_FUN.c font_cyw.c initial.c initial_cyw.c key_and_Other.c key_and_Other_cyw.c lcd_cyw.c main.c pcf8563_cyw.c ram.c ram_cyw.c stm8l15x_it.c Timer.c uart.c
    Libraries/src/: stm8l15x_adc.c stm8l15x_clk.c
