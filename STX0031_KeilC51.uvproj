# Keil uVision project STX0031_KeilC51.uvproj, settings and files
target Target 1 (MCS-51)
  device: MA82G5B32 Megawin
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) XRAM (0-0x06FF) CLOCK(25000000)
  output: STX0031-SSH (MA82G5B32_CMT2119B) Verx.xx +hex
  c flags: SizeSpeed=1
  c include: .\include;.\user\inc;.\radio
  group user
    ./user/src/: main.c sys.c gpio.c timer.c ram.c key_and_Other.c EXIT_FUN.c adc.c IAP_flash.c uart.c
  group radio
    ./radio/: cmt2300a_spi.c cmt2300a_hal.c radio.c cmt2300a.c
