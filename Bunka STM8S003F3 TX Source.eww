<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Bunka STM8S003F3 TX Source.ewp</path>
  </project>
  <batchBuild/>
</workspace>


