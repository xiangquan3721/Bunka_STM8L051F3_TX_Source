# IAR project Bunka STM8S003F3 TX Source.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L051F3 STM8L051F3
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L051; TESTMODE_DEL; NEWFUN_ADD
  ICCSTM8.CCIncludePath2: Projects\inc; Libraries\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Bunka STM8L051F3 TX Ver.hex
  ILINK.IlinkOutputFile: Bunka STM8S003F3 TX Source.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; NEWFUN_ADD; TESTMODE_DEL
  OBJCOPY.OOCOutputFile: guesturered.hex
  group (top)
    Projects/src/: ad.c adf7012.c eeprom.c EXIT_FUN.c initial.c key_and_Other.c main.c ram.c stm8l15x_it.c Timer.c uart.c uart_handle.c
