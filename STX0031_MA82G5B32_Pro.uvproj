# Keil uVision project STX0031_MA82G5B32_Pro.uvproj, settings and files
target Target 1 (MCS-51)
  device: MA82G5B32 Megawin
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) XRAM (0-0x06FF) CLOCK(25000000)
  output: STX0031_MA82G5B32_Pro +hex
  c flags: SizeSpeed=1
  c include: .\include;.\user\inc
  group user
    ./user/src/: main.c sys.c gpio.c timer.c uart.c IAP_flash.c spi.c ram.c ML7345.c ML7345_HAL.c adc.c key_and_Other.c EXIT_FUN.c
